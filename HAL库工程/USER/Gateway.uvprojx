# Keil uVision project Gateway.uvprojx, settings and files
target Gateway (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gateway
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\USER;..\CORE;..\BSP\inc;..\HALLIB\inc;..\HALLIB\inc\Legacy;..\UCOSIII\uC-CPU;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\APPLICATION\inc;..\FATFS\src;..\FATFS\src\option;..\USB\USB_HOST\USER\inc;..\USB\USB_HOST\CORE\inc;..\USB\USB_HOST\CLASS\MSC\Inc;..\USB\USB_DEVICE\USER\inc;..\USB\USB_DEVICE\CORE\inc;..\USB\USB_DEVICE\CLASS\CDC\Inc;..\LWIP;..\LWIP\api;..\LWIP\netif;..\LWIP\arch;..\LWIP\core;..\LWIP\include;..\LWIP\include\netif;..\LWIP\include\ipv4;..\LWIP\include\lwip;..\LWIP\app\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_ll_sdmmc.c
  group BSP
    ../BSP/src/: bsp_led.c bsp_key.c bsp_timer.c bsp_spi.c bsp_malloc.c bsp_lan8720.c bsp_audio.c bsp_i2c.c bsp_i2s.c bsp_esp8266.c bsp_w8801.c bsp_sdcard.c bsp.c
  group APPLICATION
    ../APPLICATION/src/: app_w25qxx.c app_wdog.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp_ucosiii.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: os_app_hooks.c
  group USB_HOST
    ../USB/USB_HOST/CORE/src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../USB/USB_HOST/CLASS/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../USB/USB_HOST/USER/src/: usb_host.c usbh_conf.c
  group USB_DEVICE
    ../USB/USB_DEVICE/CORE/src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../USB/USB_DEVICE/CLASS/CDC/Src/: usbd_cdc.c
    ../USB/USB_DEVICE/USER/src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c usbd_user.c
  group LWIP_CORE
    ../LWIP/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_NETIF
    ../LWIP/netif/: etharp.c ethernetif.c slipif.c
  group LWIP_ARCH
    ../LWIP/arch/: lwip_comm.c sys_arch.c
  group LWIP_IPV4
    ../LWIP/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_API
    ../LWIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_APP
    ../LWIP/app/src/: lwip_app_ping.c lwip_app_telnet.c lwip_app_udp.c lwip_app_httpserver.c lwip_app_tcpclient.c
