# Keil uVision project Gateway.uvprojx, settings and files
target Gateway (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Gateway +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1,USE_USB_OTG_FS
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\APPLICATION\inc;..\BSP_DRIVER\inc;..\LWIP\include;..\LWIP\include\netif;..\LWIP\netif;..\LWIP\api;..\LWIP\arch;..\LWIP\core;..\LWIP;..\LWIP\include\lwip;..\LWIP\include\ipv4;..\LWIP\app\inc;..\UCOSIII\uC-CPU;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\FATFS\src;..\FATFS\src\option;..\USB\USB_DEVICE\CLASS\MSC\inc;..\USB\USB_DEVICE\CORE\inc;..\USB\USB_DEVICE\USER\inc;..\USB\USB_DRIVER\inc;..\USB\USB_HOST\CLASS\MSC\inc;..\USB\USB_HOST\CORE\inc;..\USB\USB_HOST\USER\inc;..\AUDIO_DECODER\wav
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_fsmc.c stm32f4x7_eth.c stm32f4xx_iwdg.c
  group BSP_DRIVER
    ../BSP_DRIVER/src/: bsp.c bsp_key.c bsp_led.c bsp_timer.c bsp_uasrt.c bsp_spi.c bsp_audio.c bsp_wifi.c bsp_malloc.c bsp_i2c.c bsp_i2s.c bsp_lan8720.c
  group APPLICATION
    ../APPLICATION/src/: app_w25qxx.c app_wifi.c app_wdog.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/src/option/: cc936.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp_ucosiii.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group USB_DRIVER
    ../USB/USB_DRIVER/src/: usb_dcd_int.c usb_core.c usb_dcd.c
  group USB_DEVICE
    ../USB/USB_DEVICE/CORE/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/USB_DEVICE/CLASS/MSC/src/: usbd_msc_scsi.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c
    ../USB/USB_DEVICE/USER/src/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group LWIP_CORE
    ../LWIP/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_NETIF
    ../LWIP/netif/: etharp.c ethernetif.c slipif.c
  group LWIP_ARCH
    ../LWIP/arch/: lwip_comm.c sys_arch.c
  group LWIP_IPV4
    ../LWIP/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_API
    ../LWIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_APP
    ../LWIP/app/src/: lwip_app_ping.c lwip_app_udp.c
